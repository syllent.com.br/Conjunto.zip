Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 8ebf3d0c-e0ed-41b9-81c4-565974a46df1, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordenadas compartilhadas, ProjectSite: Terreno padrão]
File name: 0001
Time: 2025-02-11T09:02:21-03:00
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.10.25 (PTB) - IFC 24.1.10.25

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm (6)
Outros - Categoria: Níveis; Família: Nível; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: 349; Tipo: Cabeça de 8 mm
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no
Outros(Tipo) - Categoria: Níveis; Nome da família: Nível
Restrições(Tipo) - Base da elevação: Ponto base do projeto
Gráficos(Tipo) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Dados de identidade(Tipo) - Nome do tipo: Cabeça de 8 mm
Name | LongName = Nome | Elevation (mm) = Elevação (mm)
Sapata B.O. | Sapata B.O. | -4600
Sapata T.O. | Sapata T.O. | -4300
Laje T.O. | Laje T.O. | -4000
Parede da fundação T.O. | Parede da fundação T.O. | -300
Nível 1 | Nível 1 | 0
Nível 2 | Nível 2 | 4000

# IfcBuildingElementProxy: Bombas Pré-Filtro Autoescorvante:3/4cv - 220v, Bombas Pré-Filtro Autoescorvante:3/4cv - 220v:316018
In: Nível 1
Type - Material: Plástico prego - Syllent, Aço Inox, Plástico azul - Syllet, Plástico transparente_
Type - Outros - Categoria: Equipamento mecânico; 01: yes; 02: no; Nome da família: Bombas Pré-Filtro Autoescorvante
Type - Restrições - Elevação padrão: 0 mm
Type - Dados - Tabela: Super Syllent; Tabela 1: Pré filtro
Type - Cotas - a: 2.3 deg; a1: 279.5 mm; a2: 75 mm; a3: 56 mm; aa: 12 deg; Altura: 274.5 mm; Altura da saída: 201 mm; Altura do conector: 226 mm; c1: 25.5 mm; c2: 39.95 mm; c3: 42.5 mm; c4: 28.05 mm; Comprimento do motor: 316.5 mm; Comprimento total: 521 mm; DN - Recalque: 50 mm; DN - Sucção: 50 mm; e: 3 mm; e1: 5 mm; Eixo da bomba: 96.2 mm; Eixo do pré filtro: 128.7 mm; h1: 25 mm; h2: 10 mm; l1: 30 mm; l2: 44.5 mm; l3: 15 mm; l4: 3 mm; m: 10 mm; Raio 1: 5 mm; RN: 25 mm
Type - Geral - Data de criação: Dezembro de 2024; e-mail de contato:: eng.henrique@outlook.com; Família produzida por:: Marcilio Henrique M. Santos
Type - Dados de identidade - Fabricante: Syllent; Modelo: bombas pré-filtro autoescorvante 3/4CV Monofásica 220v; Nome do tipo: 3/4cv - 220v; Número OmniClass: 23.60.30.21.17; Título OmniClass: Motor Pumps; URL: https://www.syllent.com.br/produto-bomba-pre-filtro-piscina-autoescorvante
Type - Materiais e acabamentos - Carenagem: Plástico prego - Syllent; Tampa frontal: Plástico azul - Syllet; Tampa transparente: Plástico transparente_
Type - Mecânica - Classificação: Bomba
Type - Pset_ManufacturerTypeInformation - Manufacturer: Syllent
Pset_BuildingElementProxyCommon - Reference: Bombas Pré-Filtro Autoescorvante:3/4cv - 220v; sets with these values: 2
Quantidade de equipamento mecânico - Descrição da unidade: Bombas Pré-Filtro Autoescorvante; Tipo: 3/4cv - 220v; Fabricante: Syllent; Modelo: bombas pré-filtro autoescorvante 3/4CV Monofásica 220v; URL: https://www.syllent.com.br/produto-bomba-pre-filtro-piscina-autoescorvante
Outros - Família: Bombas Pré-Filtro Autoescorvante; Família e tipo: Bombas Pré-Filtro Autoescorvante: 3/4cv - 220v; ID de tipo: 315977; Tipo: 3/4cv - 220v
Restrições - Deslocamento do hospedeiro: 0 mm; Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível 1
Cotas - Área: 0.780086 m2; Volume: 0.0167884 m3
Dados de identidade - Corrente: 5.1 A; Descrição do Material: bombas pré-filtro autoescorvante 3/4CV Monofásica 220v; Fator de potêncial: 1; Marca: 1; Peso: 8.3 kg; Potência: 551.62 W; Pressão máx. na sucção: 80000 Pa; Pressão máxima: 14500 Pa; Proteção: IP 65; Temperatura máx. da água: 45 C; Temperatura mín. da água: 5 C; Tensão: 220 V; Vazão mínima: 0.666667 dm3/s
Mecânica - Classificação do sistema: Não definido
Fases - Fase criada: Fase 1

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
InPort_316018_2 | SINK
OutPort_316018_3 | SOURCE
