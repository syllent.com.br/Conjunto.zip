Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [ContentGUID: 79fc7846-b8bd-4a55-b49c-b72764612d86, VersionGUID: 7d4c1af0-3382-4ef9-aafe-f79cb3261d05, NumberOfSaves: 1], CoordinateReference [CoordinateBase: Coordenadas compartilhadas, ProjectSite: Terreno padrão]
File name: Filtro de areia.ifc
Time: 2025-02-02T15:26:54-03:00
Author: Marcilio Henrique M. Santos, eng.henrique@outlook.com
Organization: Map Projetos Inteligentes
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.0.13 (PTB) - IFC 24.3.0.13

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm (6)
Outros - Categoria: Níveis; Família: Nível; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: 349; Tipo: Cabeça de 8 mm
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no
Outros(Tipo) - Categoria: Níveis; Nome da família: Nível
Restrições(Tipo) - Base da elevação: Ponto base do projeto
Gráficos(Tipo) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Dados de identidade(Tipo) - Nome do tipo: Cabeça de 8 mm
Name | LongName = Nome | Elevation (mm) = Elevação (mm)
Sapata B.O. | Sapata B.O. | -4600
Sapata T.O. | Sapata T.O. | -4300
Laje T.O. | Laje T.O. | -4000
Parede da fundação T.O. | Parede da fundação T.O. | -300
Nível 1 | Nível 1 | 0
Nível 2 | Nível 2 | 4000

# IfcDistributionPort (3)
Description: Flow
Name | FlowDirection
OutPort_379180_1 | SOURCE
OutPort_379180_2 | SOURCE
InPort_379180_3 | SINK

# IfcFlowTerminal: Filtro de areia:SYL500, Filtro de areia:SYL500:379180
In: Nível 1
Type - Material: Plástico prego - Syllent, Aço inox, Vermelho ponteiro, Plásico preto brilhoso, Vidro do visor, Branco visor, Latão UNI EN 12165 CW617N, Plástico transparente, Plástico azul - Syllet, Plástico branco - Syllent, Plástico azul claro 01, polietileno micronizado, <Unnamed>
Type - Outros - Categoria: Peças hidrossanitárias; 01: yes; 02: no; Nome da família: Filtro de areia
Type - Restrições - Elevação padrão: 0 mm
Type - Dados - Tabela: Filtro de areia
Type - Cotas - a: 90 deg; a1: 180 deg; Altura: 720 mm; d1: 212.6 mm; Diâmetro: 500 mm; DN: 50 mm; e1: 796.3 mm; e2: 0 mm; e3: 150 mm; e4: 194.2 mm; e5: 100 mm; e6: 30.4 mm; f1: 108 mm; f2: 200 mm; f3: 196 mm; h1: 35.2 mm; h2: 684.8 mm; h3: 30 mm; h4: 45 mm; M: 4 mm; p1: 105 mm; p2: 210 mm; p3: 181.865 mm; r1: 35 mm; r2: 25 mm
Type - Geral - Data de criação: Janeiro de 2025; Família produzida por:: Marcilio Henrique M. Santos
Type - Dados de identidade - Fabricante: Syllent; Modelo: SYL500; Nome do tipo: SYL500
Type - Materiais e acabamentos - Carcaça: polietileno micronizado; Sapatas: Plástico branco - Syllent
Type - Pset_ManufacturerTypeInformation - Manufacturer: Syllent
Pset_DistributionFlowElementCommon - Reference: Filtro de areia:SYL500; sets with these values: 2
Quantidades de peças hidrossanitárias - Descrição da unidade: Filtro de areia; Tipo: SYL500; Fabricante: Syllent; Modelo: SYL500
Outros - Família: Filtro de areia; Família e tipo: Filtro de areia: SYL500; ID de tipo: 379157; Tipo: SYL500
Restrições - Deslocamento do hospedeiro: 0 mm; Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível 1
Cotas - Área: 3.46706 m2; Volume: 0.124797 m3
Geral - e-mail de contato:: eng.henrique@outlook.com
Dados de identidade - Altura manométrica total com o filtro: 103950 Pa; Área filtrante: 0.182 m2; Carga de areia: 100 kg; Descrição do Material: Filtro areia para piscina SYL500; Marca: 1; Potência da bomba: 3/4cv; Vazão nominal do conjunto: 2.52778 dm3/s
Mecânica - Classificação do sistema: Não definido
Fases - Fase criada: Fase 1
